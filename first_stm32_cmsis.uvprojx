# Keil uVision project first_stm32_cmsis.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: first_stm32_cmsis
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: main.c main.h
  group User Lib
    ./: usart.c usart.h led.c led.h delay.c delay.h DMA.c DMA.h baton.c baton.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
